options:
  parameters:
    author: Deepwave Digital
    generate_options: qt_gui
    id: airstack_rx_demo
    output_language: python
    qt_qss_theme: /usr/share/gnuradio/themes/dark.qss
    title: AirStack Demo
  states: {}

blocks:
- name: base_adc_rate
  id: variable
  parameters:
    value: int(125e6)
  states: {}
- name: freq_mhz
  id: variable_qtgui_range
  parameters:
    label: Tune Frequency (MHz)
    min_len: '600'
    start: '300'
    step: '0.5'
    stop: '6000'
    value: '700'
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    label: 'Sample Rate '
    labels: '[str(base_adc_rate), str(base_adc_rate/2), str(base_adc_rate/4), str(base_adc_rate/8), str(base_adc_rate/16) , str(base_adc_rate/32)]'
    num_opts: '0'
    options: '[base_adc_rate, base_adc_rate/2, base_adc_rate/4, base_adc_rate/8, base_adc_rate/16, base_adc_rate/32]'
    type: real
    value: base_adc_rate/16
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: freq_mhz*1e6
    fftsize: '16384'
    grid: 'True'
    name: '"FFT"'
    showports: 'True'
    type: complex
    ymax: '-30'
  states: {}
- name: soapy_airt_source_0
  id: soapy_airt_source
  parameters:
    agc: 'True'
    center_freq: freq_mhz*1e6
    dev_args: f"master_clock_rate={base_adc_rate:.3f}"
    gain0: '0'
    gain1: '0'
    nchan: '1'
    samp_rate0: samp_rate
    samp_rate1: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_airt_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
