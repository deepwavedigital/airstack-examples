<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>airstack_tx_demo</value></param>
<param><key>author</key><value>Deepwave Digital</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>qt_qss_theme</key><value>/usr/share/gnuradio/themes/dark.qss</value></param>
<param><key>title</key><value>AirStack Demo</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>base_adc_rate</value></param>
<param><key>value</key><value>125e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>bb_freq_mhz</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Baseband Frequency (MHz)</value></param>
<param><key>min_len</key><value>600</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-samp_rate/2</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>samp_rate/2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>lo_freq_mhz</value></param>
<param><key>value</key><value>2400</value></param>
<param><key>label</key><value>LO Frequency (MHz)</value></param>
<param><key>min_len</key><value>600</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>300+(samp_rate/1e6/2)</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>6000-(samp_rate/1e6/2)</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>base_adc_rate/8</value></param>
<param><key>label</key><value>Sample Rate </value></param>
<param><key>labels</key><value>[str(base_adc_rate), str(base_adc_rate/2), str(base_adc_rate/4), str(base_adc_rate/8), str(base_adc_rate/16)]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[base_adc_rate, base_adc_rate/2, base_adc_rate/4, base_adc_rate/8, base_adc_rate/16]</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>0.25</value></param>
<param><key>freq</key><value>bb_freq_mhz*1e6</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>lo_freq_mhz*1e6</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
